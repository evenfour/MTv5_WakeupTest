# Keil uVision project Even_Project.uvprojx, settings and files
target EVEN_STM32_FATFS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EF_Project +hex
  c flags: Optim=1 oTime=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,USE_USB_OTG_FS
  c include: .\CMSIS\startup;.\CMSIS;.\STDLIB\inc;.\USER;.\EFLIB;.\FATFS;.\USB\STM32_USB_Device_Library\Core\inc;.\USB\STM32_USB_Device_Library\Class\msc\inc;.\USB\STM32_USB_OTG_Driver\inc;.\USB\USB_Msc_User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ./CMSIS/: system_stm32f4xx.c stm32f4xx_conf.h
  group Startup
    ./CMSIS/startup/: startup_stm32f40_41xxx_mod.s
  group Stdlib
    ./STDLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_adc.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_pwr.c stm32f4xx_rtc.c
  group Eflib
    ./EFLIB/: EF_tick.c EF_tick.h EF_spiflash.c EF_spiflash.h EF_button.c define.h EF_button.h
  group User
    ./USER/: ads8330.c main.c stm32f4xx_it.c led.c led.h main.h stm32f4xx_it.h ads8330.h nrf2401.c nrf2401.h magnet.c magnet.h
  group Fatfs
    ./FATFS/: diskio.c diskio.h ff.c ff.h ffconf.h integer.h
    ./FATFS/option/: ccsbcs.c
  group USB_Device_Lib
    ./USB/STM32_USB_Device_Library/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
    ./USB/STM32_USB_Device_Library/Class/msc/src/: usbd_msc_bot.c usbd_msc_core.c usbd_msc_data.c usbd_msc_scsi.c
  group USB_OTG_Driver
    ./USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_dcd.c usb_dcd_int.c
  group USB_MassStorage
    ./USB/USB_Msc_User/: usb_bsp.c usbd_desc.c usbd_storage_msd.c usbd_usr.c usb_it.c
